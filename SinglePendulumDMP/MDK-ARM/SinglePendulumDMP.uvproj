# Keil uVision project SinglePendulumDMP.uvproj, settings and files
target SinglePendulumDMP Configuration (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SinglePendulumDMP Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ..\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Src\IIC; ..\Src\MPU6050; ..\Src\MPU6050\eMPL; ..\Src\delay; ..\Src\CoordinatesTrans; ..\Src\Uranus; ..\Src\Pendulum; ..\Src\GY80
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/User
    ../Src/: tim.c main.c dma.c stm32f4xx_it.c gpio.c stm32f4xx_hal_msp.c usart.c Regtarge.c Data_Receive.c Data_Transfer.c PID_Control.c sqQueue.c motor.c spi.c i2c.c
    ../Src/MPU6050/: mpu6050.c
    ../Src/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Src/IIC/: myiic.c
    ../Src/CoordinatesTrans/: coordinatetrans.c
    ../Src/Uranus/: uranus.c
    ../Src/Filter/: filter.c
    ../Src/Pendulum/: pendulumcontrol.c
    ../Src/GY80/: nine_axis_module.c
